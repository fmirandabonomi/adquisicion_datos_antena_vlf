options:
  parameters:
    author: Fernando
    generate_options: qt_gui
    id: adquisicion_banda_estrecha
    output_language: python
    title: Adquisición de banda estrecha, dos sintonías independientes (1,56 kbps)
  states: {}

blocks:
- name: archivo_salida
  id: variable
  parameters:
    value: dt.datetime.utcnow().strftime("banda_estrecha-%Y-%m-%dt%H%M%S.wav")
  states: {}
- name: bw
  id: variable
  parameters:
    value: '20'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int((samp_rate/2)/(bw*(1+fraccion_corte)/2))
  states: {}
- name: filename
  id: variable
  parameters:
    value: f"captura_{datetime.today().strftime('%Y-%m-%d-t-%H-%M-%S')}"
  states: {}
- name: fraccion_corte
  id: variable
  parameters:
    value: '.25'
  states: {}
- name: fsint
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,12
    label: Sintonía
    start: 10e3
    step: '100'
    stop: 88.2e3
    value: '24000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 72e6/(6*(56+12))
  states: {}
- name: samp_rate_salida
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: wide_fft_width
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-24000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-24800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: '2'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2**11)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2**11)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '2'
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '2'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_vector_0_0_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_streams_1
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_streams_1_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: archivo_salida
    format: FORMAT_WAV
    nchan: '8'
    samp_rate: int(samp_rate/decim)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'False'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'False'
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime as dt
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw*fraccion_corte/2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw*fraccion_corte/2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw*fraccion_corte/2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw*fraccion_corte/2
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: |-
      La tasa de muestreo en el adquisidor es (12 MHz / 68)
      = 176 8/17 kHz
    mtu: '10000'
    port: '4000'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: wide_fft_width
    freqhalf: 'False'
    gui_hint: 0,0,5,6
    name: '"Espectro antes de sintonía canal 0"'
    type: float
    update_time: wide_fft_width/samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: wide_fft_width
    freqhalf: 'False'
    gui_hint: 0,6,5,6
    name: '"Espectro antes de sintonía canal 1"'
    type: float
    update_time: wide_fft_width/samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: fsint
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 6,0,5,6
    name: '"Espectro luego de sintonía canal 0"'
    type: complex
    update_time: decim*1024/samp_rate
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: fsint
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 6,6,5,6
    name: '"Espectro luego de sintonía canal 1"'
    type: complex
    update_time: decim*1024/samp_rate
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: antena_ch0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: antena_ch1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: antena_bytes_crudo
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: antena_ch0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: antena_ch1
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_streams_to_vector_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_streams_to_vector_0_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_imag_0_0, '0', blocks_wavfile_sink_0, '5']
- [blocks_complex_to_imag_1, '0', blocks_wavfile_sink_0, '3']
- [blocks_complex_to_imag_1_0, '0', blocks_wavfile_sink_0, '7']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_wavfile_sink_0, '2']
- [blocks_complex_to_real_0_0_0, '0', blocks_wavfile_sink_0, '6']
- [blocks_complex_to_real_0_1, '0', blocks_wavfile_sink_0, '4']
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_0_0, '0']
- [blocks_deinterleave_0, '2', blocks_uchar_to_float_0_1, '0']
- [blocks_deinterleave_0, '3', blocks_uchar_to_float_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_2, '0', dc_blocker_xx_0_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_vector_to_streams_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_vector_to_streams_1_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_streams_to_vector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_streams_to_vector_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_tag_gate_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_null_sink_1_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_null_sink_1_0_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_vector_to_streams_1, '0', low_pass_filter_0, '0']
- [blocks_vector_to_streams_1, '1', low_pass_filter_0_0, '0']
- [blocks_vector_to_streams_1_0, '0', low_pass_filter_0_1, '0']
- [blocks_vector_to_streams_1_0, '1', low_pass_filter_0_0_0, '0']
- [dc_blocker_xx_0, '0', virtual_sink_0_0, '0']
- [dc_blocker_xx_0_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_imag_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_imag_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_imag_1_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_complex_to_imag_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_complex_to_real_0_1, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_streams_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_streams_to_vector_0, '1']

metadata:
  file_format: 1
