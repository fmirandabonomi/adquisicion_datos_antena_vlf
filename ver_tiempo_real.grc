options:
  parameters:
    author: Fernando
    generate_options: qt_gui
    id: ver_tiempo_real
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_cn
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,1,1,1
    label: Audio
    label0: 'OFF'
    label1: CN1
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: filename
  id: variable
  parameters:
    value: f"captura_{datetime.today().strftime('%Y-%m-%d-t-%H-%M-%S')}"
  states: {}
- name: fsint
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Sintonía
    start: '0'
    step: '100'
    stop: '80000'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Ganancia
    start: '1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2**14 * 10
  states: {}
- name: samp_rate_adq
  id: variable
  parameters:
    value: 72e6/(6*(56+12))
  states: {}
- name: vref
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-fsint'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/decim)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+"bin"
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Fernando\proyectos\rubenCorcoba\servidor\captura_15minutos_2025_08_04-12_30.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2**11)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_cn
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_adq*2
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: filename+".wav"
    format: FORMAT_WAV
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5800'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '800'
    win: window.WIN_HAMMING
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fsint
    freq_span: samp_rate
    gui_hint: 0,0,4,2
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '4000'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 6,1,2,1
    name: '"audio"'
    size: '1024'
    srate: samp_rate/decim
    type: float
    ymax: vref/2
    ymin: '-vref/2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 6,0,2,1
    name: '"crudo"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: vref/2
    ymin: '-vref/2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: (3M / 17) * (17 / 3) * (2**9/5**5) = (2**14 * 10)
    decim: 3*(5**5)
    fbw: '0.125'
    interp: 17*(2**9)
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: antena
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: antena_bytes_crudo
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: desacoplado
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: antena
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: antena_bytes_crudo
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: desacoplado
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_1, '0', virtual_sink_2, '0']
- [blocks_correctiq_0, '0', blocks_complex_to_real_1, '0']
- [blocks_correctiq_0, '0', blocks_multiply_xx_0, '0']
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_correctiq_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_1, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_deinterleave_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_null_sink_1_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_null_sink_1, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_deinterleave_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_1_0, '0', blocks_file_sink_0, '0']
- [virtual_source_1_0, '0', blocks_null_sink_0, '0']
- [virtual_source_2, '0', blocks_null_sink_2, '0']
- [virtual_source_2, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
