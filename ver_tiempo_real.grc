options:
  parameters:
    author: Fernando
    generate_options: qt_gui
    id: ver_tiempo_real
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: f"captura_{datetime.today().strftime('%Y-%m-%d-t-%H-%M-%S')}"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 72e6/(6*(56+12))
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2**11)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2**11)
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'False'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'False'
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: |-
      La tasa de muestreo en el adquisidor es (12 MHz / 68)
      = 176 8/17 kHz
    mtu: '10000'
    port: '4000'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    gui_hint: 0,0,12,6
    name: '"Espectro antena 1"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    gui_hint: 0,6,12,6
    name: '"Espectro antena 2"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: antena_ch0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: antena_ch1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: antena_bytes_crudo
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: antena_ch0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: antena_ch1
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_0_0, '0']
- [blocks_deinterleave_0, '2', blocks_uchar_to_float_0_1, '0']
- [blocks_deinterleave_0, '3', blocks_uchar_to_float_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_2, '0', dc_blocker_xx_0_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', dc_blocker_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_null_sink_1_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_null_sink_1_0_0, '0']
- [dc_blocker_xx_0, '0', virtual_sink_0_0, '0']
- [dc_blocker_xx_0_0, '0', virtual_sink_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_deinterleave_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
