options:
  parameters:
    generate_options: qt_gui
    id: analisis_datos_2026_06_30
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: decimation_a*decimation_b
  states: {}
- name: decimation_a
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decimation_b
  id: variable
  parameters:
    value: '100'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**int(np.round(np.log2(samp_rate/decimation*90)))
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frecuencia
    start: (samp_rate/decimation)/4
    step: '1'
    stop: samp_rate/2-(samp_rate/decimation)/4
    value: '21400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '176471'
  states: {}
- name: valor_max_db
  id: variable_qtgui_range
  parameters:
    label: '"Intensidad Máxima Cascada"'
    start: '-100'
    step: '1'
    stop: '10'
    value: '-70'
  states: {}
- name: valor_min_db
  id: variable_qtgui_range
  parameters:
    label: '"Intensidad Mínima Cascada"'
    start: '-150'
    step: '1'
    stop: '-60'
    value: '-140'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: '2'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '2'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*decimation*10
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*decimation*10
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lade/tesis_RubenCorcoba/adquisicion_datos_antena_vlf/banda_completa-2026-07-01t185033.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: decimation_a
    gain: '1'
    samp_rate: 6*decimation_a
    type: fir_filter_ccf
    width: 3*0.9-2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: decimation_b
    gain: '1'
    samp_rate: 6*decimation_b
    type: fir_filter_ccf
    width: 3*0.9-2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: decimation_b
    gain: '1'
    samp_rate: 6*decimation_b
    type: fir_filter_ccf
    width: 3*0.9-2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: decimation_a
    gain: '1'
    samp_rate: 6*decimation_a
    type: fir_filter_ccf
    width: 3*0.9-2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq
    fftsize: fft_size
    label1: '"Canal 1"'
    label2: '"Canal 2"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq
    fftsize: fft_size
    int_max: valor_max_db
    int_min: valor_min_db
    name: '"canal 1"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq
    fftsize: fft_size
    int_max: valor_max_db
    int_min: valor_min_db
    name: '"canal 2"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_1, '0']
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_1, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_streams_to_vector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_streams_to_vector_1, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_throttle_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_vector_to_streams_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_streams_0, '1', low_pass_filter_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '1', blocks_throttle_0_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_1, '0', low_pass_filter_0_0_0, '0']

metadata:
  file_format: 1
