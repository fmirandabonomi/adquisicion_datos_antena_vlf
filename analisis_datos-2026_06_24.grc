options:
  parameters:
    generate_options: qt_gui
    id: analisis_datos_2026_06_24
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: intensidad_max
  id: variable_qtgui_range
  parameters:
    label: '"Intensidad max dB"'
    start: '-100'
    step: '1'
    stop: '10'
    value: '-70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '25'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1000
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1000
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1000
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1000
    type: complex
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lade/tesis_RubenCorcoba/adquisicion_datos_antena_vlf/banda_estrecha-2026-07-03t150258.wav
    nchan: '8'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '"Canal 1 - 24 kHz"'
    label2: '"Canal 1 - 19,8 kHz"'
    label3: '"Canal 2 - 24 kHz"'
    label4: '"Canal 2 - 19,8 kHz"'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '24000'
    fftsize: fft_size
    int_max: intensidad_max
    name: '"Canal 1 - 24kHz"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '19800'
    fftsize: fft_size
    int_max: intensidad_max
    name: '"Canal 1 - 19,8 kHz"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '19800'
    fftsize: fft_size
    int_max: intensidad_max
    name: '"Canal 2 - 19,8 kHz"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '24000'
    fftsize: fft_size
    int_max: intensidad_max
    name: '"Canal 2 - 24 kHz"'
    type: complex
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_float_to_complex_0_1, '0', blocks_throttle_0_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [blocks_throttle_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_throttle_0_1, '0', qtgui_freq_sink_x_0, '2']
- [blocks_throttle_0_1, '0', qtgui_waterfall_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0, '2', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0, '3', blocks_float_to_complex_0_0, '1']
- [blocks_wavfile_source_0, '4', blocks_float_to_complex_0_1, '0']
- [blocks_wavfile_source_0, '5', blocks_float_to_complex_0_1, '1']
- [blocks_wavfile_source_0, '6', blocks_float_to_complex_0_0_0, '0']
- [blocks_wavfile_source_0, '7', blocks_float_to_complex_0_0_0, '1']

metadata:
  file_format: 1
